# Keil uVision project STM32F4-Discovery-blink-freertos.uvproj, settings and files
target stm32f4_blink_freertos (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: bin +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,USE_STDPERIPH_DRIVER ARM_MATH_CM4 ARM_MATH_MATRIX_CHECK __FPU_PRESENT ARM_MATH_ROUNDING __FPU_USED
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\startup;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\APP;..\Drivers\include;..\Dsp\inc;..\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: main.h main.c stm32f4xx_conf.h stm32f4xx_it.c
  group Task
    ../Task/: vShellRxGuardianTask.c vShellTxGuardianTask.c vNetworkTxGuardianTask.c vNetworkRxGuardianTask.c vTargetAssignTask.c vBCRxGuardianTask.c vBCTxGuardianTask.c vRFIDPositionUpdateTask.c vStepmotorDriveTask.c vMovingControlTask.c vPathPlanTask.c vTracelistMaintainTask.c vIdleTask.c vtime_Test_task.c vSeeTargetPosListMaintain.c vdecisionTask.c vGetYawTask.c tTimerCallback.c vCycleRecoTask.c vTraceForecastTask.c
  group APP
    ../APP/: app.h control.c network.c position_update.c Q_Shell.c ROD.c shell.c target_assign.c array.c confirm.c forecast.c Jugemotor.c kalman.c ployfit.c statPredict.c updatespace.c
  group Public
    ../Public/: Public.h RNG.c Timer2.c
  group Drivers
    ../Drivers/include/: drivers.h
    ../Drivers/src/: arduino_serial.c cc2500.c RFID_serial.c AHRS.c vedio_serial.c
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c croutine.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_rng.c
  group DSP
    ../Dsp/lib/: arm_cortexM4lf_math.lib
  group startup
    ../startup/: startup_stm32f4xx.s system_stm32f4xx.c
